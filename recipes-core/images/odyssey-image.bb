inherit image

DESCRIPTION = "Seeed Odyssey Image"

require basic-config.inc