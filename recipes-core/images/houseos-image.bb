inherit image

DESCRIPTION = "Seeed Odyssey Image"

require recipes-core/images/basic-config.inc